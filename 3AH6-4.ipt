# Autodesk Inventor part: 3AH6-4_uzsakovui
## iProperties
Created: 2006-12
Part Number: 3AH6-4_uzsakovui
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
